# Keil uVision project STM32H503CB_VL53L1CB_Project1.uvprojx, settings and files
target STM32H503CB_VL53L1CB_Project1 (6180000::V6.18::ARMCLANG)
  device: STM32H503CBTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x801FFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: STM32H503CB_VL53L1CB_Project1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H503xx
  c include: ../Core/Inc;../TOF/App;../TOF/Target;../Drivers/BSP/custom;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/Components/vl53l1cb/modules;../Drivers/BSP/Components/vl53l1cb/porting;../Drivers/BSP/Components/vl53l1cb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32h503xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c bsp.c icache.c memorymap.c custom_bus.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Application/User/TOF/Target
    ../TOF/Target/: custom_ranging_sensor.c
  group Application/User/TOF/App
    ../TOF/App/: app_tof.c
  group Drivers/BSP/custom
    ../Drivers/BSP/custom/: custom.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_cortex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_icache.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group Middlewares/X-CUBE-TOF1/Documentation
    ../Drivers/BSP/Components/Components/vl53l1cb/: LICENSE.txt
    ../Drivers/BSP/Components/Components/vl53l1cb/modules/: ReleaseNotes.txt
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/vl53l1cb/modules/: vl53l1_api.c vl53l1_api_calibration.c vl53l1_api_core.c vl53l1_api_debug.c vl53l1_api_preset_modes.c vl53l1_api_strings.c vl53l1_core.c vl53l1_core_support.c vl53l1_dmax.c vl53l1_error_strings.c vl53l1_hist_algos_gen3.c vl53l1_hist_algos_gen4.c vl53l1_hist_char.c vl53l1_hist_core.c vl53l1_hist_funcs.c vl53l1_nvm.c vl53l1_nvm_debug.c vl53l1_register_funcs.c vl53l1_sigma_estimate.c vl53l1_silicon_core.c vl53l1_wait.c vl53l1_xtalk.c vl53l1_zone_presets.c
    ../Drivers/BSP/Components/vl53l1cb/porting/: vl53l1_platform.c vl53l1_platform_ipp.c vl53l1_platform_log.c
    ../Drivers/BSP/Components/vl53l1cb/: vl53l1cb.c
software components: CMSIS:CORE 4.3.0
